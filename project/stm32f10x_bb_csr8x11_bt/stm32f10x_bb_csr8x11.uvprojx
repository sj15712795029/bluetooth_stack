# Keil uVision project stm32f10x_bb_csr8x11.uvprojx, settings and files
target stm32f10x_bb_csr8x11 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32f10x_bb_csr8x11
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\..\bsp\cortex-m3\core;..\..\bsp\cortex-m3\inc;..\..\board;..\..\board\stm32f10x;..\..\component\ringbuffer;..\..\component\bluetooth\src\include;..\..\component\bluetooth\src\include\classical;..\..\component\bluetooth\vendor;..\stm32f10x_bb_csr8x11_bt;..\..\component\bluetooth\third_party_lib\sbc;..\..\component\cjson
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group bsp
    ../../bsp/cortex-m3/core/: startup_stm32f10x_hd.s system_stm32f10x.c
    ../../bsp/cortex-m3/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group board
    ../../board/stm32f10x/: hw_led.c hw_misc.c hw_oled.c hw_systick.c hw_uart.c
  group bt
    ../../component/bluetooth/src/core/: bt_common.c bt_hci.c bt_l2cap.c bt_mem.c bt_memp.c bt_pbuf.c bt_timer.c
    ../../component/bluetooth/src/core/classical/: bt_a2dp_sink.c bt_avctp.c bt_avdtp.c bt_avrcp_controller.c bt_did.c bt_fcs.c bt_hfp_hf.c bt_map_client.c bt_obex_client.c bt_pbap_client.c bt_rfcomm.c bt_sdp.c bt_spp.c
    ../../component/bluetooth/vendor/: bt_vendor_csr8x11.c
    ../../component/bluetooth/third_party_lib/sbc/: sbc.c sbc_tables.c
  group misc
    ../../component/ringbuffer/: ringbuffer.c
  group json
    ../../component/cjson/: cJSON.c
  group app
    ./: bt_phybusif_h4.c bt_wrapper.c main.c
