# Keil uVision project stm32h750_bt.uvprojx, settings and files
target stm32f750_bt (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H750VBTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.7.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00020000) XRAM(0x30000000,0x00048000) XRAM2(0x38000000,0x00010000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: stm32h750_bt
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32H750xx
  c include: ..\..\bsp\cortex-m7\core;..\..\bsp\cortex-m7\inc;..\..\bsp\cortex-m7\inc\Legacy;..\..\board\stm32h750;..\..\component\ringbuffer;..\..\component\cjson;..\..\component\bluetooth\src\include;..\..\component\bluetooth\src\include\ble;..\..\component\bluetooth\src\include\classical;..\..\component\bluetooth\third_party_lib\sbc\sbc;..\..\component\bluetooth\vendor;..\..\component\bluetooth\wrapper;..\stm32h750_bb_bt;..\..\component\bluetooth\third_party_lib\crypto\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT6: RAM 0x30000000 size 0x48000
  memory RVCT7: RAM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group bsp
    ../../bsp/cortex-m7/core/: system_stm32h7xx.c startup_stm32h750xx.s
    ../../bsp/cortex-m7/src/: stm32h7xx_hal_cortex.c stm32h7xx_hal.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_i2s.c stm32h7xx_hal_i2s_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_usart.c stm32h7xx_hal_usart_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c
  group board
    ../../board/stm32h750/: hw_misc.c hw_systick.c hw_uart.c hw_led.c hw_button.c hw_exti.c hw_24c02.c bsp_iic.c
  group bt
    ../../component/bluetooth/src/core/: bt_common.c bt_hci.c bt_l2cap.c bt_mem.c bt_memp.c bt_pbuf.c bt_snoop.c bt_timer.c
    ../../component/bluetooth/src/core/classical/: bt_a2dp_sink.c bt_avctp.c bt_avdtp.c bt_avrcp_controller.c bt_did.c bt_fcs.c bt_hfp_hf.c bt_hid_device.c bt_map_client.c bt_obex_client.c bt_pbap_client.c bt_rfcomm.c bt_sdp.c bt_spp.c
    ../../component/bluetooth/src/core/ble/: bt_att.c bt_bas.c bt_gatt.c bt_smp.c bt_smp_key.c
    ../../component/bluetooth/vendor/: bt_vendor_bcm4345c5.c bt_vendor_bcm43430a1.c bt_vendor_csr8x11.c bt_vendor_cyw43438.c bt_vendor_cyw54591.c bt_vendor_manager.c
    ../../component/bluetooth/third_party_lib/sbc/sbc/: sbc.c sbc_primitives.c
    ../../component/bluetooth/wrapper/: bt_wrapper.c
    ../../component/bluetooth/third_party_lib/crypto/source/: aes_decrypt.c aes_encrypt.c cbc_mode.c ccm_mode.c cmac_mode.c ctr_mode.c ctr_prng.c ecc.c ecc_dh.c ecc_dsa.c ecc_platform_specific.c hmac.c hmac_prng.c sha256.c utils.c
  group misc
    ../../component/ringbuffer/: ringbuffer.c
    ../../component/cjson/: cJSON.c
  group app
    ./: main.c bt_a2dp_playback.c bt_phybusif_h4.c
