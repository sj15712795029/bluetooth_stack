# Keil uVision project stm32f407_bt.uvguix.uvprojx, settings and files
target stm32f407_csr8311 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: stm32f407_bt +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ..\..\bsp\cortex-m4\core;..\..\bsp\cortex-m4\inc;..\..\bsp\cortex-m4\inc\Legacy;..\..\board;..\..\board\stm32f407;..\..\component\fs;..\..\component\fs\fatfs13\source;..\..\component\bluetooth\src\include;..\..\component\bluetooth\src\include\classical;..\..\component\bluetooth\third_party_lib\sbc\sbc;..\..\component\bluetooth\vendor;..\..\component\bluetooth\wrapper;..\..\component\ringbuffer;..\..\component\cjson;..\stm32f407_bb_bt;..\..\component\memory_manager;..\..\component\bluetooth\src\include\ble;..\..\component\bluetooth\third_party_lib\crypto\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group bsp
    ../../bsp/cortex-m4/core/: system_stm32f4xx.c startup_stm32f407xx.s
    ../../bsp/cortex-m4/src/: stm32f4xx_hal.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_exti.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_spi.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_sram.c
  group board
    ../../board/stm32f407/: hw_misc.c hw_led.c hw_uart.c hw_systick.c hw_spi_flash.c hw_sht2x.c hw_lcd.c
  group bt
    ../../component/bluetooth/src/core/: bt_common.c bt_hci.c bt_l2cap.c bt_mem.c bt_memp.c bt_pbuf.c bt_snoop.c bt_timer.c
    ../../component/bluetooth/src/core/classical/: bt_a2dp_sink.c bt_avctp.c bt_avdtp.c bt_avrcp_controller.c bt_did.c bt_fcs.c bt_hfp_hf.c bt_map_client.c bt_obex_client.c bt_pbap_client.c bt_rfcomm.c bt_sdp.c bt_spp.c bt_hid_device.c
    ../../component/bluetooth/vendor/: bt_vendor_csr8x11.c bt_vendor_manager.c bt_vendor_bcm43430a1.c bt_vendor_bcm4345c5.c
    ../../component/bluetooth/wrapper/: bt_wrapper.c
    ../../component/bluetooth/third_party_lib/sbc/sbc/: sbc.c sbc_primitives.c
    ../../component/bluetooth/src/core/ble/: bt_att.c bt_bas.c bt_gatt.c bt_smp.c bt_smp_key.c
    ../../component/bluetooth/third_party_lib/crypto/source/: aes_decrypt.c aes_encrypt.c cbc_mode.c ccm_mode.c cmac_mode.c ctr_mode.c ctr_prng.c ecc.c ecc_dh.c ecc_dsa.c ecc_platform_specific.c hmac.c hmac_prng.c sha256.c utils.c
  group misc
    ../../component/ringbuffer/: ringbuffer.c
    ../../component/memory_manager/: memory_manager.c
  group json
    ../../component/cjson/: cJSON.c
  group app
    ./: main.c bt_phybusif_h4.c bt_a2dp_playback.c
  group fs
    ../../component/fs/: fs_wrapper.c
    ../../component/fs/fatfs13/source/: diskio.c ff.c ffsystem.c ffunicode.c
