# Keil uVision project stm32f412_bt.uvprojx, settings and files
target stm32f412_bt (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F412RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x00040000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: stm32f412_bt
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F412Rx
  c include: ..\..\bsp\cortex-m4\core;..\..\bsp\cortex-m4\inc;..\..\board\stm32f412;..\..\board;..\..\component\fs;..\..\component\bluetooth\src\include;..\..\component\bluetooth\src\include\classical;..\..\component\bluetooth\vendor;..\..\component\bluetooth\wrapper;..\..\component\bluetooth\third_party_lib\sbc\sbc;..\..\component\ringbuffer;..\..\component\fs;..\..\component\fs\fatfs13\source;..\..\component\cjson;..\stm32f412_bb_bt;..\..\bsp\cortex-m4\STM32_USB_Device_Library\Core\Inc;..\..\bsp\cortex-m4\STM32_USB_Device_Library\Class\MSC\Inc;..\..\board\stm32f412\usb_mass_storage;..\..\component\bluetooth\src\include\ble
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group bsp
    ../../bsp/cortex-m4/core/: system_stm32f4xx.c startup_stm32f412rx.s
    ../../bsp/cortex-m4/src/: stm32f4xx_hal.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_exti.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_spi.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_ll_usb.c
    ../../bsp/cortex-m4/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../../bsp/cortex-m4/STM32_USB_Device_Library/Class/MSC/Src/: usbd_msc.c usbd_msc_bot.c usbd_msc_data.c usbd_msc_scsi.c
  group board
    ../../board/stm32f412/: hw_led.c hw_misc.c hw_uart.c hw_systick.c hw_button.c hw_exti.c hw_oled.c hw_spi_flash.c hw_sht2x.c
    ../../board/stm32f412/usb_mass_storage/: usb_device.c usbd_conf.c usbd_desc.c usbd_storage_if.c
  group bt
    ../../component/bluetooth/src/core/: bt_common.c bt_hci.c bt_l2cap.c bt_mem.c bt_memp.c bt_pbuf.c bt_timer.c
    ../../component/bluetooth/src/core/classical/: bt_a2dp_sink.c bt_avctp.c bt_avdtp.c bt_avrcp_controller.c bt_did.c bt_fcs.c bt_hfp_hf.c bt_map_client.c bt_obex_client.c bt_pbap_client.c bt_rfcomm.c bt_sdp.c bt_spp.c bt_hid_device.c
    ../../component/bluetooth/vendor/: bt_vendor_csr8x11.c bt_vendor_bcm43430a1.c bt_vendor_manager.c
    ../../component/bluetooth/wrapper/: bt_wrapper.c
    ../../component/bluetooth/third_party_lib/sbc/sbc/: sbc.c sbc_primitives.c
    ../../component/bluetooth/src/core/ble/: bt_att.c bt_bas.c bt_gatt.c
  group misc
    ../../component/ringbuffer/: ringbuffer.c
  group json
    ../../component/cjson/: cJSON.c
  group app
    ./: main.c bt_phybusif_h4.c bt_a2dp_playback.c
  group fs
    ../../component/fs/: fs_wrapper.c
    ../../component/fs/fatfs13/source/: diskio.c ff.c ffsystem.c ffunicode.c
